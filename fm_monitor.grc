<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fm_monitor</value></param>
<param><key>author</key><value>Zouppen</value></param>
<param><key>description</key><value>Outputs Icinga passive check compatible format about SNR and deviation</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Monitors FM broadcast SNR and deviation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>deviation</value></param>
<param><key>value</key><value>90e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>monitor_rate</value></param>
<param><key>value</key><value>2*target_deviation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rms_avg</value></param>
<param><key>value</key><value>0.00001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target_deviation</value></param>
<param><key>value</key><value>75e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>upsample_rf</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>monitor_rate/(3.14159*2*target_deviation)</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0_0_2</value></param>
<param><key>alpha</key><value>rms_avg</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0_0_2_0</value></param>
<param><key>alpha</key><value>rms_avg</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_rms_xx</key>
<param><key>id</key><value>blocks_rms_xx_0_0_2_0_0</value></param>
<param><key>alpha</key><value>rms_avg</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector_decimator</key>
<param><key>id</key><value>blocks_stream_to_vector_decimator_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>sample_rate</key><value>monitor_rate</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>vec_rate</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_vector_decimator</key>
<param><key>id</key><value>blocks_stream_to_vector_decimator_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>sample_rate</key><value>monitor_rate</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>vec_rate</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_vector_decimator</key>
<param><key>id</key><value>blocks_stream_to_vector_decimator_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>sample_rate</key><value>monitor_rate</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>vec_rate</key><value>1</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>-offtune</value></param>
<param><key>decim</key><value>upsample_rf</value></param>
<param><key>samp_rate</key><value>monitor_rate*upsample_rf</value></param>
<param><key>taps</key><value>firdes.complex_band_pass(1,monitor_rate*upsample_rf,-deviation,deviation, 1e4)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>center_freq</key><value>-offtune-noise_offset</value></param>
<param><key>decim</key><value>upsample_rf</value></param>
<param><key>samp_rate</key><value>monitor_rate*upsample_rf</value></param>
<param><key>taps</key><value>firdes.complex_band_pass(1,monitor_rate*upsample_rf,-noise_bw/2,noise_bw/2, 1e4*noise_bw/deviation/2)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>Frequency in MHz</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RF gain (dB)</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>gr_icinga_dev</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, service="", warn=0, crit=1):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Icinga',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.service = service
        self.warn = warn
        self.crit = crit

    def work(self, input_items, output_items):
        """Test limits based on ranges"""
        status = 0
        if self.crit &lt; self.warn:
            if input_items[0] &lt; self.warn: status = 1
            if input_items[0] &lt; self.crit: status = 2
        else:
            if input_items[0] &gt; self.warn: status = 1
            if input_items[0] &gt; self.crit: status = 2
        
        if status == 0: text = "OK"
        if status == 1: text = "WARNING"
        if status == 2: text = "CRITICAL"
        print("{};{};{}: {}".format(self.service,status,text,input_items[0][0]))
        
        return 1
</value></param>
<param><key>crit</key><value>0.1</value></param>
<param><key>service</key><value>"Vappuradio deviation"</value></param>
<param><key>warn</key><value>0.3</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>gr_icinga_snr</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, service="", warn=0, crit=1):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Icinga',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.service = service
        self.warn = warn
        self.crit = crit

    def work(self, input_items, output_items):
        """Test limits based on ranges"""
        status = 0
        if self.crit &lt; self.warn:
            if input_items[0] &lt; self.warn: status = 1
            if input_items[0] &lt; self.crit: status = 2
        else:
            if input_items[0] &gt; self.warn: status = 1
            if input_items[0] &gt; self.crit: status = 2
        
        if status == 0: text = "OK"
        if status == 1: text = "WARNING"
        if status == 2: text = "CRITICAL"
        print("{};{};{}: {}".format(self.service,status,text,input_items[0][0]))
        
        return 1
</value></param>
<param><key>crit</key><value>20</value></param>
<param><key>service</key><value>"Vappuradio SNR"</value></param>
<param><key>warn</key><value>25</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>imports</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_bw</value></param>
<param><key>label</key><value>Noise source bandwidth around noise_offset (Hz)</value></param>
<param><key>short_id</key><value>N</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>20000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>noise_offset</value></param>
<param><key>label</key><value>Offset for noise measurement relative to center frequency (Hz)</value></param>
<param><key>short_id</key><value>n</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-150000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>offtune</value></param>
<param><key>label</key><value>Tuner offset to avoid LO peak (Hz)</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>135000</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>(1e6*frequency)+offtune</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>monitor_rate*upsample_rf</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>snr</value></param>
<param><key>bw_ratio</key><value>noise_bw/deviation/2</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import math
import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, bw_ratio=1.0):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='SNR decibel',   # will show up in GRC
            in_sig=[np.float32,np.float32],
            out_sig=[np.float32]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.bw_ratio_bel = math.log10(bw_ratio)

    def work(self, input_items, output_items):
        """example: multiply with constant"""
    
        # Signal voltage in bels
        signal_bel = math.log10(input_items[0])
        # Noise voltage in bel
        noise_bel = math.log10(input_items[1])
        # SNR is (signal/noise + bandwidth)**2 * scaling constant but in log scale.
        snr = 10*(2*(signal_bel - noise_bel) + self.bw_ratio_bel)
        # Output in decibels
        output_items[0][:] = snr
        return len(output_items[0])
</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_rms_xx_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0_0_2</source_block_id><sink_block_id>blocks_stream_to_vector_decimator_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0_0_2_0</source_block_id><sink_block_id>blocks_stream_to_vector_decimator_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_rms_xx_0_0_2_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_decimator_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_decimator_0</source_block_id><sink_block_id>gr_icinga_dev</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_decimator_0_0</source_block_id><sink_block_id>snr</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_decimator_0_0_0</source_block_id><sink_block_id>snr</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_rms_xx_0_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_rms_xx_0_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>snr</source_block_id><sink_block_id>gr_icinga_snr</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
